options:
  parameters:
    author: N6RFM
    generate_options: qt_gui
    id: A239Alferov
    output_language: python
    title: 239Alferov
  states: {}

blocks:
- name: BFO
  id: variable_qtgui_range
  parameters:
    start: '-5000'
    step: '100'
    stop: '5000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      Low-overhead live audio path (parallel to the existing KISS decode chain) — no file I/O.

      -50000/(2*3.14159265*4800)
    gain: '.2'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(freq-nfreq+offset)+BFO'
    offset: '0'
    phase: '0'
    samp_rate: '2500000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Routes to the pipeline virtual sink automatically via the import_pulse_sink_0 block above — no manual PULSE_SINK needed.
    device_name: '"pulse"'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/bob/Desktop/
    basefile: 239Alferov
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: 'False'
    sampleRate: '50000'
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: filerepeater_TimeOfDay_0_0
  id: filerepeater_TimeOfDay
  parameters:
    hours: '3'
    minutes: '53'
    seconds: '0'
    triggerTime: '600'
  states: {state: disabled}
- name: filerepeater_TimeOfDay_0_0_0
  id: filerepeater_TimeOfDay
  parameters:
    hours: '5'
    minutes: '26'
    seconds: '0'
    triggerTime: '600'
  states: {state: disabled}
- name: filerepeater_TimeOfDay_0_0_1
  id: filerepeater_TimeOfDay
  parameters:
    hours: '15'
    minutes: '58'
    seconds: '0'
    triggerTime: '600'
  states: {}
- name: filter_width
  id: parameter
  parameters:
    label: FM filter width
    type: eng_float
    value: '20000'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: 436.272e6
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: gpredict_port
    verbose: 'False'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4531'
  states: {}
- name: import_pulse_sink_0
  id: import
  parameters:
    comment: Forces the Audio Sink to route into the pipeline's virtual sink automatically — no need to set PULSE_SINK manually before launching.
    imports: |-
      import os
      os.environ['PULSE_SINK'] = 'alferov_pipe'
  states: {}
- name: kiss_port
  id: parameter
  parameters:
    label: kiss_port
    short_id: k
    type: intx
    value: '8100'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '6000'
    win: window.WIN_HAMMING
  states: {}
- name: nfreq
  id: parameter
  parameters:
    label: Nominal Frequency
    type: eng_float
    value: 436.272e6
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: driver=airspy,serial=466c64c8323184c7,soapy=0
    bb_gain0: '15'
    biast: 'False'
    freq0: nfreq-offset
    gain0: '21'
    gain_mode0: 'False'
    gain_table: sensitivity
    if_gain0: '15'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: overflow_monitor_overflow_tag_monitor_0
  id: overflow_monitor_overflow_tag_monitor
  parameters:
    log_dir: /home/bob/Desktop
    log_filename: pass_log.csv
    sample_rate: samp_rate
    satellite: alferov
  states: {}
- name: port
  id: parameter
  parameters:
    label: port
    type: intx
    value: '7355'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '50000'
    fc: '0'
    fftsize: '1024'
    name: 239Alferov
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 50 kHz (post low-pass) -> 48 kHz standard audio rate
    decim: '50000'
    interp: '48000'
    type: fff
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_kiss_file_sink_0_0
  id: satellites_kiss_file_sink
  parameters:
    append: 'True'
    file: /home/bob/Desktop/239Alferov_noPDU2KISS.kss
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/bob/gr-satellites/python/satyaml/239Alferov.yml
    iq: 'True'
    norad: '44013'
    options: ''
    samp_rate: '50000'
  states: {}
- name: satellites_telemetry_submit_0
  id: satellites_telemetry_submit
  parameters:
    norad: '64881'
    server: '"SatNOGS"'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [filerepeater_TimeOfDay_0_0, trigger, filerepeater_AdvFileSink_0, recordstate]
- [filerepeater_TimeOfDay_0_0_0, trigger, filerepeater_AdvFileSink_0, recordstate]
- [filerepeater_TimeOfDay_0_0_1, trigger, filerepeater_AdvFileSink_0, recordstate]
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', filerepeater_AdvFileSink_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', satellites_satellite_decoder_0, '0']
- [osmosdr_source_1, '0', overflow_monitor_overflow_tag_monitor_0, '0']
- [overflow_monitor_overflow_tag_monitor_0, '0', blocks_multiply_xx_1, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [satellites_print_timestamp_0, out, satellites_hexdump_sink_0, in]
- [satellites_print_timestamp_0, out, satellites_kiss_file_sink_0_0, in]
- [satellites_print_timestamp_0, out, satellites_telemetry_submit_0, in]
- [satellites_satellite_decoder_0, out, satellites_print_timestamp_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
